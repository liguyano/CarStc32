# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART3 +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC32G_Delay.c STC32G_GPIO.c STC32G_NVIC.c STC32G_UART.c STC32G_UART_Isr.c I2C.h I2C.c ATC02.h ATC02.c SHT35.h SHT35.c Air724.h Air724.c
